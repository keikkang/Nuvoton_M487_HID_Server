# Keil uVision project LwIP_HID_Server.uvproj, settings and files
target LwIP_TCP_HID_Server (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: M487JIDAE Nuvoton
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x7FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: LwIP_TCP_EchoServer +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: RVDS_ARMCM4_NUC4xx
  c misc: --diag_suppress=550,177,C4017,111
  c include: ..\..\Library\UsbHostLib\inc;..\..\Library\CMSIS\Include;..\..\ThirdParty\lwIP\src\include;..\..\ThirdParty\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\Library\StdDriver\inc;..\..\Library\Device\Nuvoton\M480\Include;..\..\ThirdParty\FreeRTOS\Source\include;..\..\ThirdParty\FreeRTOS\Demo\Common\include;..\..\board_lwip\include;..\..\LwIP_HID_Server
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ../../Library/Device/Nuvoton/M480/Source/: system_M480.c
    ../../Library/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
  group User
    ../: main.c tcp_echoserver-netconn.c descriptors.c hid_kb.c usb_hid_keys.h main.h extern.h
  group FreeRTOS
    ../../ThirdParty/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../ThirdParty/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../ThirdParty/FreeRTOS/Demo/Common/Minimal/: GenQTest.c PollQ.c QueueSet.c semtest.c
  group Library
    ../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c usbd.c
  group lwIP
    ../../ThirdParty/lwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys_lwip.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../ThirdParty/lwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../ThirdParty/lwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../ThirdParty/lwIP/src/netif/: ethernet.c
    ../../board_lwip/: sys_arch.c time_stamp.c
    ../../board_lwip/netif/: ethernetif.c m480_eth.c
